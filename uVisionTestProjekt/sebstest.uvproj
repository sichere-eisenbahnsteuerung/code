# Keil uVision project sebstest.uvproj, settings and files
target Target 1 (MCS-51)
  device: C515C-L Infineon
  cpu: IRAM(0-0xFF) CLOCK(10000000) XRAM (0xF800-0xFFFF) MOD517DP
  output: sebstest
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 test.c test.h
