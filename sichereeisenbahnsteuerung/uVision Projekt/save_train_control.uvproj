# Keil uVision project save_train_control.uvproj, settings and files
target Target 1 (MCS-51)
  device: C515C-L Infineon
  cpu: IRAM(0-0xFF) CLOCK(10000000) XRAM (0xF800-0xFFFF) MOD517DP
  output: save_train_control +hex
  c flags: Optimize=9 SizeSpeed=1
  group C-Files
    ../: AuditingSystem.c Befehlsvalidierung.c Betriebsmittelverwaltung.c Ergebnisvalidierung.c Fahrprogramm.c Leitzentrale.c Notaus.c RS232Treiber.c S88Treiber.c SoftwareWatchdog.c SSCTreiber.c
  group H-Files
    ../: AuditingSystem.h AuditingSystemReportAllMsg.h AuditingSystemSendMsg.h Befehlsvalidierung.h Betriebsmittelverwaltung.h Ergebnisvalidierung.h Fahrprogramm.h Leitzentrale.h Notaus.h RS232Treiber.h S88Treiber.h SoftwareWatchdog.h SoftwareWatchdogHelloModul.h SoftwareWatchdogStop.h SSCTreiber.h
